v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/gnd.sym} 650 -300 0 0 {name=l33 lab=GND}
C {devices/lab_wire.sym} 410 -420 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 410 -110 2 1 {name=l67 sig_type=std_logic lab=Vout_n}
C {devices/lab_wire.sym} 410 -300 2 1 {name=l73 sig_type=std_logic lab=Vout_p}
C {devices/ipin.sym} 190 -250 0 0 {name=p1 lab=Vin_n}
C {devices/iopin.sym} 130 -370 0 0 {name=p2 lab=VDD}
C {devices/iopin.sym} 130 -330 0 0 {name=p3 lab=GND}
C {devices/ipin.sym} 190 -290 0 0 {name=p4 lab=Vin_p}
C {devices/opin.sym} 130 -210 0 0 {name=p5 lab=Vout_n}
C {devices/lab_wire.sym} 540 -230 0 0 {name=l1 sig_type=std_logic lab=Vin_n}
C {devices/lab_wire.sym} 540 -420 0 0 {name=l2 sig_type=std_logic lab=Vin_p}
C {devices/opin.sym} 130 -170 0 0 {name=p6 lab=Vout_p}
C {devices/iopin.sym} 130 -130 0 0 {name=p7 lab=Vb4}
C {tia-sscs-pico-2021/schem/sf_half.sym} 370 -360 0 0 {name=X1}
C {tia-sscs-pico-2021/schem/sf_half.sym} 370 -170 0 0 {name=X2}
C {devices/lab_wire.sym} 410 -230 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 650 -110 0 0 {name=l5 lab=GND}
C {devices/lab_wire.sym} 540 -110 2 1 {name=l6 sig_type=std_logic lab=Vb4}
C {devices/lab_wire.sym} 540 -300 2 1 {name=l7 sig_type=std_logic lab=Vb4}
